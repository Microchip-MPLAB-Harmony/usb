<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\cdc_com_port_single_sam_e70_xult.ewp</path>
    </project>
    <batchBuild />
</workspace>
