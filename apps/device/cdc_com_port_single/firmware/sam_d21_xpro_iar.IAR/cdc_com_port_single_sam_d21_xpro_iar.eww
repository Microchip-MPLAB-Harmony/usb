<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\cdc_com_port_single_sam_d21_xpro_iar.ewp</path>
    </project>
</workspace>
