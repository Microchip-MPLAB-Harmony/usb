# IAR project cdc_com_port_single_sam_sam_9x60_ek.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9260 Microchip AT91SAM9260
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_9x60_ek; ..\src\packs\SAM9X60_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS; ..\..\firmware\src; ..\..\firmware\src\config\sam_9x60_ek; ..\..\firmware\src\packs\SAM9X60_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\firmware\src; ..\..\firmware\src\config\sam_9x60_ek; ..\..\firmware\src\packs\SAM9X60_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ILINK.IlinkOutputFile: cdc_com_port_single_sam_sam_9x60_ek.out
  ILINK.IlinkIcfFile: ..\src\config\sam_9x60_ek\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app.h
    ../src/config/sam_9x60_ek/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/config/sam_9x60_ek
    ../src/config/sam_9x60_ek/: configuration.h definitions.h device_cache.h toolchain_specifics.h user.h
  group Harmony3/Header Files/config/sam_9x60_ek/bsp
    ../src/config/sam_9x60_ek/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_9x60_ek/driver
    ../src/config/sam_9x60_ek/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_9x60_ek/driver/usb
    ../src/config/sam_9x60_ek/driver/usb/: drv_usb.h
  group Harmony3/Header Files/config/sam_9x60_ek/driver/usb/udphs
    ../src/config/sam_9x60_ek/driver/usb/udphs/: drv_usb_udphs.h
  group Harmony3/Header Files/config/sam_9x60_ek/driver/usb/udphs/src
    ../src/config/sam_9x60_ek/driver/usb/udphs/src/: drv_usb_udphs_local.h drv_usb_udphs_variant_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/aic
    ../src/config/sam_9x60_ek/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/clk
    ../src/config/sam_9x60_ek/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/mmu
    ../src/config/sam_9x60_ek/peripheral/mmu/: cp15.h plib_mmu.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/pio
    ../src/config/sam_9x60_ek/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_9x60_ek/system
    ../src/config/sam_9x60_ek/system/: system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_9x60_ek/system/cache
    ../src/config/sam_9x60_ek/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_9x60_ek/system/debug
    ../src/config/sam_9x60_ek/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_9x60_ek/system/int
    ../src/config/sam_9x60_ek/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek/usb
    ../src/config/sam_9x60_ek/usb/: usb_cdc.h usb_chapter_9.h usb_common.h usb_device.h usb_device_cdc.h usb_host.h usb_host_client_driver.h usb_host_hub_interface.h usb_hub.h
  group Harmony3/Header Files/config/sam_9x60_ek/usb/src
    ../src/config/sam_9x60_ek/usb/src/: usb_device_cdc_local.h usb_device_function_driver.h usb_device_local.h usb_device_mapping.h usb_external_dependencies.h
  group Harmony3/Header Files/packs/SAM9X60_DFP
    ../src/packs/SAM9X60_DFP/: device.h sam9x60.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/component
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/pio
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
  group Harmony3/Linker File
    ../src/config/sam_9x60_ek/: ddram.icf
  group Harmony3/Source Files
    ../src/: app.c main.c
  group Harmony3/Source Files/config/sam_9x60_ek
    ../src/config/sam_9x60_ek/: cstartup.s initialization.c interrupts.c tasks.c usb_device_init_data.c vectortrap.s
  group Harmony3/Source Files/config/sam_9x60_ek/bsp
    ../src/config/sam_9x60_ek/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_9x60_ek/driver/usb/udphs/src
    ../src/config/sam_9x60_ek/driver/usb/udphs/src/: drv_usb_udphs.c drv_usb_udphs_device.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/aic
    ../src/config/sam_9x60_ek/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/clk
    ../src/config/sam_9x60_ek/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/mmu
    ../src/config/sam_9x60_ek/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/pio
    ../src/config/sam_9x60_ek/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_9x60_ek/stdio
    ../src/config/sam_9x60_ek/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_9x60_ek/system/cache
    ../src/config/sam_9x60_ek/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_9x60_ek/system/int
    ../src/config/sam_9x60_ek/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_9x60_ek/usb/src
    ../src/config/sam_9x60_ek/usb/src/: usb_device.c usb_device_cdc.c usb_device_cdc_acm.c
