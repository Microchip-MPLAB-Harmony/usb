# IAR project cdc_com_port_single_sam_d11_xpro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD11D14AM Microchip ATSAMD11D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_d11_xpro_iar; ..\..\firmware\src\packs\ATSAMD11D14AM_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: cdc_com_port_single_sam_d11_xpro.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_d11_xpro_iar/: sam_d11_xpro_iar.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/ATSAMD11D14AM_DFP/component/: ac.h adc.h dac.h dmac.h dsu.h eic.h evsys.h gclk.h hmatrixb.h mtb.h nvmctrl.h pac.h pm.h port.h ptc.h rtc.h sercom.h sysctrl.h tc.h tcc.h usb.h wdt.h
    ../src/: app.h
    ../src/packs/ATSAMD11D14AM_DFP/: atsamd11d14am.h device.h
    ../src/config/sam_d11_xpro_iar/bsp/: bsp.h
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
    ../src/config/sam_d11_xpro_iar/: configuration.h definitions.h device_cache.h toolchain_specifics.h user.h
    ../src/config/sam_d11_xpro_iar/driver/: driver.h driver_common.h
    ../src/config/sam_d11_xpro_iar/driver/usb/: drv_usb.h drv_usb_external_dependencies.h
    ../src/config/sam_d11_xpro_iar/driver/usb/usbfsv1/: drv_usbfsv1.h
    ../src/config/sam_d11_xpro_iar/driver/usb/usbfsv1/src/: drv_usbfsv1_local.h drv_usbfsv1_variant_mapping.h
    ../src/config/sam_d11_xpro_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/config/sam_d11_xpro_iar/peripheral/clock/: plib_clock.h
    ../src/config/sam_d11_xpro_iar/peripheral/evsys/: plib_evsys.h
    ../src/config/sam_d11_xpro_iar/peripheral/nvic/: plib_nvic.h
    ../src/config/sam_d11_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.h
    ../src/config/sam_d11_xpro_iar/peripheral/port/: plib_port.h
    ../src/packs/ATSAMD11D14AM_DFP/pio/: samd11d14am.h
    ../src/config/sam_d11_xpro_iar/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_d11_xpro_iar/system/: system.h system_common.h system_module.h
    ../src/config/sam_d11_xpro_iar/usb/: usb_cdc.h usb_chapter_9.h usb_common.h usb_device.h usb_device_cdc.h usb_host.h usb_host_client_driver.h usb_host_hub_interface.h usb_hub.h
    ../src/config/sam_d11_xpro_iar/usb/src/: usb_device_cdc_local.h usb_device_function_driver.h usb_device_local.h usb_device_mapping.h usb_external_dependencies.h
  group IAR Project Connection File/Source Files
    ../src/: app.c main.c
    ../src/config/sam_d11_xpro_iar/bsp/: bsp.c
    ../src/config/sam_d11_xpro_iar/driver/usb/usbfsv1/src/: drv_usbfsv1.c drv_usbfsv1_device.c
    ../src/config/sam_d11_xpro_iar/: exceptions.c initialization.c interrupts.c startup_iar.c tasks.c usb_device_init_data.c
    ../src/config/sam_d11_xpro_iar/stdio/: iar_monitor.c
    ../src/config/sam_d11_xpro_iar/peripheral/clock/: plib_clock.c
    ../src/config/sam_d11_xpro_iar/peripheral/evsys/: plib_evsys.c
    ../src/config/sam_d11_xpro_iar/peripheral/nvic/: plib_nvic.c
    ../src/config/sam_d11_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.c
    ../src/config/sam_d11_xpro_iar/peripheral/port/: plib_port.c
    ../src/config/sam_d11_xpro_iar/system/int/src/: sys_int.c
    ../src/config/sam_d11_xpro_iar/usb/src/: usb_device.c usb_device_cdc.c usb_device_cdc_acm.c
