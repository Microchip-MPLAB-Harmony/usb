# IAR project Backup of printer_basic_sam_9x60_ek.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_9x60_ek; ..\..\firmware\src\packs\SAM9X60_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: printer_basic_sam_9x60_ek.out
  ILINK.IlinkIcfFile: ..\..\firmware\src\config\sam_9x60_ek\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_9x60_ek/: sam_9x60_ek.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
    ../src/: app.h
    ../src/config/sam_9x60_ek/bsp/: bsp.h
    ../src/config/sam_9x60_ek/: configuration.h definitions.h device_cache.h toolchain_specifics.h user.h
    ../src/config/sam_9x60_ek/peripheral/mmu/: cp15.h plib_mmu.h
    ../src/packs/SAM9X60_DFP/: device.h sam9x60.h
    ../src/config/sam_9x60_ek/driver/: driver.h driver_common.h
    ../src/config/sam_9x60_ek/driver/usart/: drv_usart.h drv_usart_definitions.h
    ../src/config/sam_9x60_ek/driver/usb/: drv_usb.h
    ../src/config/sam_9x60_ek/driver/usb/udphs/: drv_usb_udphs.h
    ../src/config/sam_9x60_ek/driver/usb/udphs/src/: drv_usb_udphs_local.h drv_usb_udphs_variant_mapping.h
    ../src/config/sam_9x60_ek/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/config/sam_9x60_ek/peripheral/aic/: plib_aic.h
    ../src/config/sam_9x60_ek/peripheral/clk/: plib_clk.h
    ../src/config/sam_9x60_ek/peripheral/dbgu/: plib_dbgu.h plib_dbgu_common.h
    ../src/config/sam_9x60_ek/peripheral/pio/: plib_pio.h
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
    ../src/config/sam_9x60_ek/system/cache/: sys_cache.h
    ../src/config/sam_9x60_ek/system/dma/: sys_dma.h sys_dma_mapping.h
    ../src/config/sam_9x60_ek/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_9x60_ek/system/: system.h system_common.h system_module.h
    ../src/config/sam_9x60_ek/usb/: usb_chapter_9.h usb_common.h usb_device.h usb_device_printer.h usb_host.h usb_host_client_driver.h usb_host_hub_interface.h usb_hub.h usb_printer.h
    ../src/config/sam_9x60_ek/usb/src/: usb_device_function_driver.h usb_device_local.h usb_device_mapping.h usb_device_printer_local.h usb_external_dependencies.h
  group IAR Project Connection File/Source Files
    ../src/: app.c main.c
    ../src/config/sam_9x60_ek/bsp/: bsp.c
    ../src/config/sam_9x60_ek/: cstartup.s exceptions.c initialization.c interrupts.c tasks.c usb_device_init_data.c vectortrap.s
    ../src/config/sam_9x60_ek/driver/usart/src/: drv_usart.c drv_usart_local.h
    ../src/config/sam_9x60_ek/driver/usb/udphs/src/: drv_usb_udphs.c drv_usb_udphs_device.c
    ../src/config/sam_9x60_ek/stdio/: iar_monitor.c
    ../src/config/sam_9x60_ek/peripheral/aic/: plib_aic.c
    ../src/config/sam_9x60_ek/peripheral/clk/: plib_clk.c
    ../src/config/sam_9x60_ek/peripheral/dbgu/: plib_dbgu.c
    ../src/config/sam_9x60_ek/peripheral/mmu/: plib_mmu.c
    ../src/config/sam_9x60_ek/peripheral/pio/: plib_pio.c
    ../src/config/sam_9x60_ek/system/cache/: sys_cache.c
    ../src/config/sam_9x60_ek/system/dma/: sys_dma.c
    ../src/config/sam_9x60_ek/system/int/src/: sys_int.c
    ../src/config/sam_9x60_ek/usb/src/: usb_device.c usb_device_printer.c
