<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\hid_basic_sam_a5d2_xult_iar.ewp</path>
    </project>
</workspace>
