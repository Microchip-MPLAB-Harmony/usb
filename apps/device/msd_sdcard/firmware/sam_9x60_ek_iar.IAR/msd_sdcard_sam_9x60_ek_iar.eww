<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\msd_sdcard_sam_9x60_ek_iar.ewp</path>
    </project>
    <batchBuild />
</workspace>
