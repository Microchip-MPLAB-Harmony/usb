<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\cdc_basic_sam_a5d2_xult_freertos_iar.ewp</path>
    </project>
</workspace>
