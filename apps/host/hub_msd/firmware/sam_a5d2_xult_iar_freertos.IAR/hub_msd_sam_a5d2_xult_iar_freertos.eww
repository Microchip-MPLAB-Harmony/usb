<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\hub_msd_sam_a5d2_xult_iar_freertos.ewp</path>
    </project>
</workspace>
