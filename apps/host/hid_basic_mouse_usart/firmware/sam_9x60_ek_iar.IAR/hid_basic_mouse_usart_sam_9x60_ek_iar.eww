<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\hid_basic_mouse_usart_sam_9x60_ek_iar.ewp</path>
    </project>
</workspace>
