<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sam_a5d2_xult.IAR.ewp</path>
    </project>
    <batchBuild />
</workspace>
