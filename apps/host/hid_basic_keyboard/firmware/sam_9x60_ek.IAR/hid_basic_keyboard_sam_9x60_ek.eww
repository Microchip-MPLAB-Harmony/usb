<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\hid_basic_keyboard_sam_9x60.ewp</path>
    </project>
    <batchBuild />
</workspace>
