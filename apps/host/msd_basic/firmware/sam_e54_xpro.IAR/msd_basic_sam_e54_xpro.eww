<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\msd_basic_sam_e54_xpro.ewp</path>
    </project>
    <batchBuild />
</workspace>
