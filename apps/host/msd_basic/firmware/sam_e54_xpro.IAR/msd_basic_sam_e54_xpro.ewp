# IAR project msd_basic_sam_e54_xpro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME54P20A Microchip ATSAME54P20A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_e54_xpro_iar; ..\..\firmware\src\packs\ATSAME54P20A_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: msd_basic_sam_e54_xpro.srec
  ILINK.IlinkOutputFile: msd_basic_sam_e54_xpro.out
  ILINK.IlinkIcfFile: C:\Repos\H3\usb\apps\host\msd_basic\firmware\src\config\sam_e54_xpro_iar\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_e54_xpro_iar/: sam_e54_xpro_iar.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/ATSAME54P20A_DFP/component/: ac.h adc.h aes.h can.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h gmac.h hmatrixb.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h pm.h port.h pukcc.h qspi.h ramecc.h rstc.h rtc.h sdhc.h sercom.h supc.h tc.h tcc.h trng.h usb.h wdt.h
    ../src/: app.h
    ../src/packs/ATSAME54P20A_DFP/: atsame54p20a.h device.h
    ../src/config/sam_e54_xpro_iar/bsp/: bsp.h
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
    ../src/config/sam_e54_xpro_iar/: configuration.h definitions.h device_cache.h toolchain_specifics.h user.h
    ../src/config/sam_e54_xpro_iar/system/fs/fat_fs/src/hardware_access/: diskio.h
    ../src/config/sam_e54_xpro_iar/driver/: driver.h driver_common.h
    ../src/config/sam_e54_xpro_iar/driver/usb/: drv_usb.h drv_usb_external_dependencies.h
    ../src/config/sam_e54_xpro_iar/driver/usb/usbfsv1/: drv_usbfsv1.h
    ../src/config/sam_e54_xpro_iar/driver/usb/usbfsv1/src/: drv_usbfsv1_local.h drv_usbfsv1_variant_mapping.h
    ../src/config/sam_e54_xpro_iar/system/fs/fat_fs/src/file_system/: ff.h ffconf.h
    ../src/config/sam_e54_xpro_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/config/sam_e54_xpro_iar/peripheral/clock/: plib_clock.h
    ../src/config/sam_e54_xpro_iar/peripheral/cmcc/: plib_cmcc.h
    ../src/config/sam_e54_xpro_iar/peripheral/evsys/: plib_evsys.h
    ../src/config/sam_e54_xpro_iar/peripheral/nvic/: plib_nvic.h
    ../src/config/sam_e54_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.h
    ../src/config/sam_e54_xpro_iar/peripheral/port/: plib_port.h
    ../src/config/sam_e54_xpro_iar/peripheral/sercom/usart/: plib_sercom2_usart.h plib_sercom_usart_common.h
    ../src/config/sam_e54_xpro_iar/peripheral/tc/: plib_tc0.h plib_tc_common.h
    ../src/packs/ATSAME54P20A_DFP/pio/: same54p20a.h
    ../src/config/sam_e54_xpro_iar/usb/: scsi.h usb_chapter_9.h usb_common.h usb_host.h usb_host_client_driver.h usb_host_hub_interface.h usb_host_msd.h usb_host_scsi.h usb_hub.h usb_msd.h
    ../src/config/sam_e54_xpro_iar/system/cache/: sys_cache.h
    ../src/config/sam_e54_xpro_iar/system/fs/: sys_fs.h sys_fs_media_manager.h
    ../src/config/sam_e54_xpro_iar/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h
    ../src/config/sam_e54_xpro_iar/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_e54_xpro_iar/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_e54_xpro_iar/system/time/src/: sys_time_local.h
    ../src/config/sam_e54_xpro_iar/system/: system.h system_common.h system_media.h system_module.h
    ../src/config/sam_e54_xpro_iar/usb/src/: usb_external_dependencies.h usb_host_hub_mapping.h usb_host_local.h usb_host_msd_local.h usb_host_scsi_local.h
  group IAR Project Connection File/Source Files
    ../src/: app.c main.c
    ../src/config/sam_e54_xpro_iar/bsp/: bsp.c
    ../src/config/sam_e54_xpro_iar/system/fs/fat_fs/src/: diskio.c ff.c
    ../src/config/sam_e54_xpro_iar/driver/usb/usbfsv1/src/: drv_usbfsv1.c drv_usbfsv1_host.c
    ../src/config/sam_e54_xpro_iar/: exceptions.c initialization.c interrupts.c startup_iar.c tasks.c usb_host_init_data.c
    ../src/config/sam_e54_xpro_iar/stdio/: iar_monitor.c
    ../src/config/sam_e54_xpro_iar/peripheral/clock/: plib_clock.c
    ../src/config/sam_e54_xpro_iar/peripheral/cmcc/: plib_cmcc.c
    ../src/config/sam_e54_xpro_iar/peripheral/evsys/: plib_evsys.c
    ../src/config/sam_e54_xpro_iar/peripheral/nvic/: plib_nvic.c
    ../src/config/sam_e54_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.c
    ../src/config/sam_e54_xpro_iar/peripheral/port/: plib_port.c
    ../src/config/sam_e54_xpro_iar/peripheral/sercom/usart/: plib_sercom2_usart.c
    ../src/config/sam_e54_xpro_iar/peripheral/tc/: plib_tc0.c
    ../src/config/sam_e54_xpro_iar/system/cache/: sys_cache.c
    ../src/config/sam_e54_xpro_iar/system/fs/src/: sys_fs.c sys_fs_media_manager.c
    ../src/config/sam_e54_xpro_iar/system/int/src/: sys_int.c
    ../src/config/sam_e54_xpro_iar/system/time/src/: sys_time.c
    ../src/config/sam_e54_xpro_iar/usb/src/: usb_host.c usb_host_msd.c usb_host_scsi.c
