# IAR project msd_basic_sam_d21_xpro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Microchip ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_d21_xpro; ..\..\firmware\src\packs\ATSAMD21J18A_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: msd_basic_sam_d21_xpro.out
  ILINK.IlinkIcfFile: ..\src\config\sam_d21_xpro\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ../src/config/sam_d21_xpro/: flash.icf sam_d21_xpro.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/ATSAMD21J18A_DFP/component/: ac.h adc.h dac.h dmac.h dsu.h eic.h evsys.h gclk.h hmatrixb.h i2s.h mtb.h nvmctrl.h pac.h pm.h port.h ptc.h rtc.h sercom.h sysctrl.h tc.h tcc.h usb.h wdt.h
    ../src/: app.h
    ../src/packs/CMSIS/CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
    ../src/packs/ATSAMD21J18A_DFP/: atsamd21j18a.h device.h
    ../src/config/sam_d21_xpro/bsp/: bsp.h
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h tz_context.h
    ../src/config/sam_d21_xpro/: configuration.h definitions.h device_cache.h toolchain_specifics.h user.h
    ../src/config/sam_d21_xpro/system/fs/fat_fs/src/hardware_access/: diskio.h
    ../src/config/sam_d21_xpro/driver/: driver.h driver_common.h
    ../src/config/sam_d21_xpro/driver/usb/: drv_usb.h drv_usb_external_dependencies.h
    ../src/config/sam_d21_xpro/driver/usb/usbfsv1/: drv_usbfsv1.h
    ../src/config/sam_d21_xpro/driver/usb/usbfsv1/src/: drv_usbfsv1_local.h drv_usbfsv1_variant_mapping.h
    ../src/config/sam_d21_xpro/system/fs/fat_fs/src/file_system/: ff.h ffconf.h
    ../src/config/sam_d21_xpro/system/fs/mpfs/: mpfs.h
    ../src/config/sam_d21_xpro/system/fs/mpfs/src/: mpfs_local.h
    ../src/config/sam_d21_xpro/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/config/sam_d21_xpro/peripheral/clock/: plib_clock.h
    ../src/config/sam_d21_xpro/peripheral/evsys/: plib_evsys.h
    ../src/config/sam_d21_xpro/peripheral/nvic/: plib_nvic.h
    ../src/config/sam_d21_xpro/peripheral/nvmctrl/: plib_nvmctrl.h
    ../src/config/sam_d21_xpro/peripheral/port/: plib_port.h
    ../src/config/sam_d21_xpro/peripheral/sercom/usart/: plib_sercom3_usart.h plib_sercom_usart_common.h
    ../src/config/sam_d21_xpro/peripheral/tc/: plib_tc3.h plib_tc_common.h
    ../src/packs/ATSAMD21J18A_DFP/pio/: samd21j18a.h
    ../src/config/sam_d21_xpro/usb/: scsi.h usb_chapter_9.h usb_common.h usb_host.h usb_host_client_driver.h usb_host_hub_interface.h usb_host_msd.h usb_host_scsi.h usb_hub.h usb_msd.h
    ../src/config/sam_d21_xpro/system/fs/: sys_fs.h sys_fs_media_manager.h
    ../src/config/sam_d21_xpro/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h
    ../src/config/sam_d21_xpro/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_d21_xpro/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_d21_xpro/system/time/src/: sys_time_local.h
    ../src/config/sam_d21_xpro/system/: system.h system_common.h system_media.h system_module.h
    ../src/config/sam_d21_xpro/usb/src/: usb_external_dependencies.h usb_host_hub_mapping.h usb_host_local.h usb_host_msd_local.h usb_host_scsi_local.h
  group IAR Project Connection File/Source Files
    ../src/: app.c main.c
    ../src/config/sam_d21_xpro/bsp/: bsp.c
    ../src/config/sam_d21_xpro/system/fs/fat_fs/src/: diskio.c ff.c
    ../src/config/sam_d21_xpro/driver/usb/usbfsv1/src/: drv_usbfsv1.c drv_usbfsv1_host.c
    ../src/config/sam_d21_xpro/: exceptions.c initialization.c interrupts.c startup_iar.c tasks.c usb_host_init_data.c
    ../src/config/sam_d21_xpro/stdio/: iar_monitor.c
    ../src/config/sam_d21_xpro/system/fs/mpfs/src/: mpfs.c
    ../src/config/sam_d21_xpro/peripheral/clock/: plib_clock.c
    ../src/config/sam_d21_xpro/peripheral/evsys/: plib_evsys.c
    ../src/config/sam_d21_xpro/peripheral/nvic/: plib_nvic.c
    ../src/config/sam_d21_xpro/peripheral/nvmctrl/: plib_nvmctrl.c
    ../src/config/sam_d21_xpro/peripheral/port/: plib_port.c
    ../src/config/sam_d21_xpro/peripheral/sercom/usart/: plib_sercom3_usart.c
    ../src/config/sam_d21_xpro/peripheral/tc/: plib_tc3.c
    ../src/config/sam_d21_xpro/system/fs/src/: sys_fs.c sys_fs_media_manager.c
    ../src/config/sam_d21_xpro/system/int/src/: sys_int.c
    ../src/config/sam_d21_xpro/system/time/src/: sys_time.c
    ../src/config/sam_d21_xpro/usb/src/: usb_host.c usb_host_msd.c usb_host_scsi.c
