<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\msd_basic_sam_d21_xpro.ewp</path>
    </project>
    <batchBuild />
</workspace>
