<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\msd_basic_sam_e54_xpro_iar.ewp</path>
    </project>
</workspace>
