# IAR project msd_basic_sam_d21_xpro_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Microchip ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_d21_xpro_iar; ..\src\packs\ATSAMD21J18A_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS; .; ..\src\config\sam_d21_xpro_iar\system\fs\fat_fs\file_system; ..\src\config\sam_d21_xpro_iar\system\fs\fat_fs\hardware_access
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: sam_d21_xpro_iar.out
  ILINK.IlinkIcfFile: ..\src\config\sam_d21_xpro_iar\flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar
    ../src/config/sam_d21_xpro_iar/: device_cache.h toolchain_specifics.h definitions.h device.h user.h configuration.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/peripheral/nvmctrl
    ../src/config/sam_d21_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/peripheral/evsys
    ../src/config/sam_d21_xpro_iar/peripheral/evsys/: plib_evsys.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/peripheral/port
    ../src/config/sam_d21_xpro_iar/peripheral/port/: plib_port.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/peripheral/clock
    ../src/config/sam_d21_xpro_iar/peripheral/clock/: plib_clock.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/peripheral/nvic
    ../src/config/sam_d21_xpro_iar/peripheral/nvic/: plib_nvic.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/peripheral/tc
    ../src/config/sam_d21_xpro_iar/peripheral/tc/: plib_tc_common.h plib_tc3.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/usb
    ../src/config/sam_d21_xpro_iar/usb/: usb_host_msd.h usb_host_scsi.h usb_msd.h scsi.h usb_host.h usb_common.h usb_chapter_9.h usb_host_client_driver.h usb_host_hub_interface.h usb_hub.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/usb/src
    ../src/config/sam_d21_xpro_iar/usb/src/: usb_host_msd_local.h usb_host_scsi_local.h usb_host_local.h usb_host_hub_mapping.h usb_external_dependencies.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/system
    ../src/config/sam_d21_xpro_iar/system/: system.h system_common.h system_module.h system_media.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/system/time
    ../src/config/sam_d21_xpro_iar/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_d21_xpro_iar/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/system/fs
    ../src/config/sam_d21_xpro_iar/system/fs/: sys_fs.h sys_fs_media_manager.h sys_fs_fat_interface.h
    ../src/config/sam_d21_xpro_iar/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/system/fs/fat_fs/file_system
    ../src/config/sam_d21_xpro_iar/system/fs/fat_fs/file_system/: ff.h ffconf.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/system/fs/fat_fs/hardware_access
    ../src/config/sam_d21_xpro_iar/system/fs/fat_fs/hardware_access/: diskio.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/system/int
    ../src/config/sam_d21_xpro_iar/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/system/debug
    ../src/config/sam_d21_xpro_iar/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/bsp
    ../src/config/sam_d21_xpro_iar/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/driver
    ../src/config/sam_d21_xpro_iar/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/driver/usb
    ../src/config/sam_d21_xpro_iar/driver/usb/: drv_usb.h drv_usb_external_dependencies.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/driver/usb/usbfsv1
    ../src/config/sam_d21_xpro_iar/driver/usb/usbfsv1/: drv_usbfsv1.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/driver/usb/usbfsv1/src
    ../src/config/sam_d21_xpro_iar/driver/usb/usbfsv1/src/: drv_usbfsv1_variant_mapping.h drv_usbfsv1_local.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/osal
    ../src/config/sam_d21_xpro_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/packs/ATSAMD21J18A_DFP
    ../src/packs/ATSAMD21J18A_DFP/: atsamd21j18a.h
  group Harmony3/Header Files/packs/ATSAMD21J18A_DFP/component
    ../src/packs/ATSAMD21J18A_DFP/component/: ac.h adc.h dac.h dmac.h dsu.h eic.h evsys.h gclk.h hmatrixb.h i2s.h mtb.h nvmctrl.h pac.h pm.h port.h ptc.h rtc.h sercom.h sysctrl.h tc.h tcc.h usb.h wdt.h
  group Harmony3/Header Files/packs/ATSAMD21J18A_DFP/pio
    ../src/packs/ATSAMD21J18A_DFP/pio/: samd21j18a.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core/Include
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm0plus.h mpu_armv7.h cachel1_armv7.h
  group Harmony3/Source Files
    ../src/: main.c app.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar
    ../src/config/sam_d21_xpro_iar/: initialization.c interrupts.c exceptions.c startup_iar.c usb_host_init_data.c tasks.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/peripheral/nvmctrl
    ../src/config/sam_d21_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/peripheral/evsys
    ../src/config/sam_d21_xpro_iar/peripheral/evsys/: plib_evsys.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/peripheral/port
    ../src/config/sam_d21_xpro_iar/peripheral/port/: plib_port.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/peripheral/clock
    ../src/config/sam_d21_xpro_iar/peripheral/clock/: plib_clock.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/peripheral/nvic
    ../src/config/sam_d21_xpro_iar/peripheral/nvic/: plib_nvic.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/peripheral/tc
    ../src/config/sam_d21_xpro_iar/peripheral/tc/: plib_tc3.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/usb/src
    ../src/config/sam_d21_xpro_iar/usb/src/: usb_host_msd.c usb_host_scsi.c usb_host.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/stdio
    ../src/config/sam_d21_xpro_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/system/time
    ../src/config/sam_d21_xpro_iar/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/system/fs
    ../src/config/sam_d21_xpro_iar/system/fs/src/: sys_fs.c sys_fs_media_manager.c sys_fs_fat_interface.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/system/fs/fat_fs/file_system
    ../src/config/sam_d21_xpro_iar/system/fs/fat_fs/file_system/: ff.c ffunicode.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/system/fs/fat_fs/hardware_access
    ../src/config/sam_d21_xpro_iar/system/fs/fat_fs/hardware_access/: diskio.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/system/int
    ../src/config/sam_d21_xpro_iar/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/bsp
    ../src/config/sam_d21_xpro_iar/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/driver/usb/usbfsv1/src
    ../src/config/sam_d21_xpro_iar/driver/usb/usbfsv1/src/: drv_usbfsv1.c drv_usbfsv1_host.c
  group Harmony3/Linker File
    ../src/config/sam_d21_xpro_iar/: flash.icf
