# IAR project msd_basic_sam_e70_xult.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_e70_xult; ..\..\firmware\src\packs\ATSAME70Q21B_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: msd_basic_sam_e70_xult.out
  ILINK.IlinkIcfFile: ..\src\config\sam_d21_xpro\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_e70_xult/: flash.icf sam_e70_xult.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/ATSAME70Q21B_DFP/component/: acc.h aes.h afec.h chipid.h dacc.h efc.h gmac.h gpbr.h hsmci.h i2sc.h icm.h isi.h matrix.h mcan.h pio.h pmc.h pwm.h qspi.h rstc.h rswdt.h rtc.h rtt.h sdramc.h smc.h spi.h ssc.h supc.h tc.h trng.h twihs.h uart.h usart.h usbhs.h utmi.h wdt.h xdmac.h
    ../src/: app.h
    ../src/packs/CMSIS/CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
    ../src/packs/ATSAME70Q21B_DFP/: atsame70q21b.h device.h
    ../src/config/sam_e70_xult/bsp/: bsp.h
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h tz_context.h
    ../src/config/sam_e70_xult/: configuration.h definitions.h device_cache.h toolchain_specifics.h user.h
    ../src/config/sam_e70_xult/system/fs/fat_fs/src/hardware_access/: diskio.h
    ../src/config/sam_e70_xult/driver/: driver.h driver_common.h
    ../src/config/sam_e70_xult/driver/usb/: drv_usb.h drv_usb_external_dependencies.h
    ../src/config/sam_e70_xult/driver/usb/usbhsv1/: drv_usbhsv1.h
    ../src/config/sam_e70_xult/driver/usb/usbhsv1/src/: drv_usbhsv1_local.h drv_usbhsv1_variant_mapping.h
    ../src/config/sam_e70_xult/system/fs/fat_fs/src/file_system/: ff.h ffconf.h
    ../src/config/sam_e70_xult/system/fs/mpfs/: mpfs.h
    ../src/config/sam_e70_xult/system/fs/mpfs/src/: mpfs_local.h
    ../src/config/sam_e70_xult/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/config/sam_e70_xult/peripheral/clk/: plib_clk.h
    ../src/config/sam_e70_xult/peripheral/efc/: plib_efc.h
    ../src/config/sam_e70_xult/peripheral/nvic/: plib_nvic.h
    ../src/config/sam_e70_xult/peripheral/pio/: plib_pio.h
    ../src/config/sam_e70_xult/peripheral/tc/: plib_tc0.h plib_tc_common.h
    ../src/packs/ATSAME70Q21B_DFP/pio/: same70q21b.h
    ../src/config/sam_e70_xult/usb/: scsi.h usb_chapter_9.h usb_common.h usb_host.h usb_host_client_driver.h usb_host_hub_interface.h usb_host_msd.h usb_host_scsi.h usb_hub.h usb_msd.h
    ../src/config/sam_e70_xult/system/cache/: sys_cache.h
    ../src/config/sam_e70_xult/system/fs/: sys_fs.h sys_fs_media_manager.h
    ../src/config/sam_e70_xult/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h
    ../src/config/sam_e70_xult/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_e70_xult/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_e70_xult/system/time/src/: sys_time_local.h
    ../src/config/sam_e70_xult/system/: system.h system_common.h system_media.h system_module.h
    ../src/config/sam_e70_xult/usb/src/: usb_external_dependencies.h usb_host_hub_mapping.h usb_host_local.h usb_host_msd_local.h usb_host_scsi_local.h
  group IAR Project Connection File/Source Files
    ../src/: app.c main.c
    ../src/config/sam_e70_xult/bsp/: bsp.c
    ../src/config/sam_e70_xult/system/fs/fat_fs/src/: diskio.c ff.c
    ../src/config/sam_e70_xult/driver/usb/usbhsv1/src/: drv_usbhsv1.c drv_usbhsv1_host.c
    ../src/config/sam_e70_xult/: exceptions.c initialization.c interrupts.c startup_iar.c tasks.c usb_host_init_data.c
    ../src/config/sam_e70_xult/stdio/: iar_monitor.c
    ../src/config/sam_e70_xult/system/fs/mpfs/src/: mpfs.c
    ../src/config/sam_e70_xult/peripheral/clk/: plib_clk.c
    ../src/config/sam_e70_xult/peripheral/efc/: plib_efc.c
    ../src/config/sam_e70_xult/peripheral/nvic/: plib_nvic.c
    ../src/config/sam_e70_xult/peripheral/pio/: plib_pio.c
    ../src/config/sam_e70_xult/peripheral/tc/: plib_tc0.c
    ../src/config/sam_e70_xult/system/cache/: sys_cache.c
    ../src/config/sam_e70_xult/system/fs/src/: sys_fs.c sys_fs_media_manager.c
    ../src/config/sam_e70_xult/system/int/src/: sys_int.c
    ../src/config/sam_e70_xult/system/time/src/: sys_time.c
    ../src/config/sam_e70_xult/usb/src/: usb_host.c usb_host_msd.c usb_host_scsi.c
