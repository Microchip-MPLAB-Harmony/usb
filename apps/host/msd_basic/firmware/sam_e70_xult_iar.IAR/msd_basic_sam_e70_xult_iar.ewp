# IAR project msd_basic_sam_e70_xult_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCIncludePath2: .; ..\src\config\sam_e70_xult_iar\system\fs\fat_fs\file_system; ..\src\config\sam_e70_xult_iar\system\fs\fat_fs\hardware_access; ..\src; ..\src\config\sam_e70_xult_iar; ..\src\packs\ATSAME70Q21B_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: sam_e70_xult_iar.out
  ILINK.IlinkIcfFile: ..\src\config\sam_e70_xult_iar\flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/config/sam_e70_xult_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/: app.h
  group Harmony3/Header Files/config/sam_e70_xult_iar
    ../src/config/sam_e70_xult_iar/: device_cache.h toolchain_specifics.h definitions.h user.h configuration.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/driver
    ../src/config/sam_e70_xult_iar/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/driver/usb
    ../src/config/sam_e70_xult_iar/driver/usb/: drv_usb.h drv_usb_external_dependencies.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/driver/usb/usbhsv1
    ../src/config/sam_e70_xult_iar/driver/usb/usbhsv1/: drv_usbhsv1.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/driver/usb/usbhsv1/src
    ../src/config/sam_e70_xult_iar/driver/usb/usbhsv1/src/: drv_usbhsv1_variant_mapping.h drv_usbhsv1_local.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/usb
    ../src/config/sam_e70_xult_iar/usb/: usb_host_client_driver.h usb_host_hub_interface.h usb_host.h usb_hub.h usb_common.h usb_chapter_9.h usb_host_msd.h usb_host_scsi.h usb_msd.h scsi.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/usb/src
    ../src/config/sam_e70_xult_iar/usb/src/: usb_host_local.h usb_host_hub_mapping.h usb_external_dependencies.h usb_host_msd_local.h usb_host_scsi_local.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/bsp
    ../src/config/sam_e70_xult_iar/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/system
    ../src/config/sam_e70_xult_iar/system/: system.h system_common.h system_module.h system_media.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/system/fs
    ../src/config/sam_e70_xult_iar/system/fs/: sys_fs.h sys_fs_media_manager.h sys_fs_fat_interface.h
    ../src/config/sam_e70_xult_iar/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/system/fs/fat_fs/file_system
    ../src/config/sam_e70_xult_iar/system/fs/fat_fs/file_system/: ff.h ffconf.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/system/fs/fat_fs/hardware_access
    ../src/config/sam_e70_xult_iar/system/fs/fat_fs/hardware_access/: diskio.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/system/int
    ../src/config/sam_e70_xult_iar/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/system/cache
    ../src/config/sam_e70_xult_iar/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/system/debug
    ../src/config/sam_e70_xult_iar/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/system/time
    ../src/config/sam_e70_xult_iar/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_e70_xult_iar/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/peripheral/clk
    ../src/config/sam_e70_xult_iar/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/peripheral/pio
    ../src/config/sam_e70_xult_iar/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/peripheral/nvic
    ../src/config/sam_e70_xult_iar/peripheral/nvic/: plib_nvic.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/peripheral/efc
    ../src/config/sam_e70_xult_iar/peripheral/efc/: plib_efc.h
  group Harmony3/Header Files/config/sam_e70_xult_iar/peripheral/tc
    ../src/config/sam_e70_xult_iar/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/packs/ATSAME70Q21B_DFP
    ../src/packs/ATSAME70Q21B_DFP/: device.h atsame70q21b.h
  group Harmony3/Header Files/packs/ATSAME70Q21B_DFP/component
    ../src/packs/ATSAME70Q21B_DFP/component/: acc.h aes.h afec.h chipid.h dacc.h efc.h gmac.h gpbr.h hsmci.h i2sc.h icm.h isi.h matrix.h mcan.h pio.h pmc.h pwm.h qspi.h rstc.h rswdt.h rtc.h rtt.h sdramc.h smc.h spi.h ssc.h supc.h tc.h trng.h twihs.h uart.h usart.h usbhs.h utmi.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/ATSAME70Q21B_DFP/pio
    ../src/packs/ATSAME70Q21B_DFP/pio/: same70q21b.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core/Include
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm7.h mpu_armv7.h
  group Harmony3/Source Files
    ../src/: main.c app.c
  group Harmony3/Source Files/config/sam_e70_xult_iar
    ../src/config/sam_e70_xult_iar/: usb_host_init_data.c initialization.c interrupts.c exceptions.c startup_iar.c tasks.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/driver/usb/usbhsv1/src
    ../src/config/sam_e70_xult_iar/driver/usb/usbhsv1/src/: drv_usbhsv1.c drv_usbhsv1_host.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/usb/src
    ../src/config/sam_e70_xult_iar/usb/src/: usb_host.c usb_host_msd.c usb_host_scsi.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/bsp
    ../src/config/sam_e70_xult_iar/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/system/fs
    ../src/config/sam_e70_xult_iar/system/fs/src/: sys_fs.c sys_fs_media_manager.c sys_fs_fat_interface.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/system/fs/fat_fs/file_system
    ../src/config/sam_e70_xult_iar/system/fs/fat_fs/file_system/: ff.c ffunicode.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/system/fs/fat_fs/hardware_access
    ../src/config/sam_e70_xult_iar/system/fs/fat_fs/hardware_access/: diskio.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/system/int
    ../src/config/sam_e70_xult_iar/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/system/cache
    ../src/config/sam_e70_xult_iar/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/system/time
    ../src/config/sam_e70_xult_iar/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/stdio
    ../src/config/sam_e70_xult_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/peripheral/clk
    ../src/config/sam_e70_xult_iar/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/peripheral/pio
    ../src/config/sam_e70_xult_iar/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/peripheral/nvic
    ../src/config/sam_e70_xult_iar/peripheral/nvic/: plib_nvic.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/peripheral/efc
    ../src/config/sam_e70_xult_iar/peripheral/efc/: plib_efc.c
  group Harmony3/Source Files/config/sam_e70_xult_iar/peripheral/tc
    ../src/config/sam_e70_xult_iar/peripheral/tc/: plib_tc0.c
  group Harmony3/Linker File
    ../src/config/sam_e70_xult_iar/: flash.icf
